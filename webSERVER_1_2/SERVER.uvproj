# Keil uVision project SERVER.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: SERVER
  c flags: Optim=1 uC99=1
  c define: MG_ARCH=MG_ARCH_WIN32
  c include: .\srcCODE;.\.vscode
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s
    ./srcCODE/: mongoose_config.h ENC28J60.h sys_stat_h.h mongoose_custom_config.h lpc214x.h portable_restrict.h main.c mongoose_custom_impl.c mongoose.c mongoose.h direct.h ws2tcpip.h unistd.h process.h winerror.h winsock2.h windows.h sys_time.h sys_select.h sys_type.h sys_socket.h netinet_in.h arpa_inet.h std_bool.h custom_errno.h
